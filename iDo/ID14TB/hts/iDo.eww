<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\iDo.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>iDo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>iDo</project>
        <configuration>CC2541DK-Sensor-OAD-ImgA</configuration>
      </member>
      <member>
        <project>iDo</project>
        <configuration>CC2541DK-Sensor-OAD-ImgB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


