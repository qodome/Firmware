# IAR project BIM.ewp, settings and files
configuration CC254xF256 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\app; ..\hal\include; ..\hal\target\CC2540EB
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  ICC8051.IccLang: 0
  XLINK.XclFile: bim_cc254x.xcl
  group APP
    ../app/: bim_ivec.s51 bim_main.c
  group HAL
    ../hal/target/CC2540EB/: hal_flash.c
    ../hal/include/: hal_flash.h
