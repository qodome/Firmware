# IAR project iDo.ewp, settings and files
configuration iDo-OAD-ImgA (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=FALSE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_I2C=FALSE; HAL_ADC=TRUE; DEBUG_STATS; DEBUG_MEM
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: common; include; hal\include; hal\target\CC2541ST; osal\include; services\saddr; ble\include; ble\controller\phy; ble\controller\include; ble\hci; ble\host; common\cc2540; common\npi\npi_np; Profiles\Roles; Profiles\SensorProfile; Profiles\Keys; Profiles\DevInfo; Profiles\Temperature; Profiles\iDo_Stats; Profiles\HIDDev; Profiles\Batt; Profiles\Oad; Profiles\DataRecorder; Profiles\MemDump; Profiles\CurrentTime; App
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  postbuild: "common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "iDo-OAD-ImgA\Exe\iDo"
  XLINK.XclFile: common\cc2540\cc254x_f256_imgA.xcl
configuration iDo-OAD-ImgB (8051)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=FALSE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_I2C=FALSE; HAL_ADC=TRUE; DEBUG_STATS; DEBUG_MEM
  postbuild: "common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "iDo-OAD-ImgB\Exe\iDo"
  XLINK.XclFile: common\cc2540\cc254x_f256_imgB.xcl
configuration iDo-ImgA-for-flash (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD; OAD_KEEP_NV_PAGES; FEATURE_OAD_BIM; HAL_IMAGE_A; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=FALSE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_I2C=FALSE; HAL_ADC=TRUE; DEBUG_STATS; DEBUG_MEM
  postbuild: "perl" "C:\_Software_\util\combine_hex.pl" "C:\Texas Instruments\BLE-CC254x-1.4.0\Projects\ble\util\BIM_custom_dn\cc254x\CC254xF256\Exe\BIM_CC254xF256.hex" "iDo-ImgA-for-flash\Exe\iDo.hex" "iDo-ImgA-for-flash\Exe\combo.hex"
configuration _old_iDo-OAD-ImgA (8051)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=FALSE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_I2C=FALSE; HAL_ADC=TRUE; OLD_BOARD; DEBUG_MEM; DEBUG_STATS
  postbuild: "common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "_old_iDo-OAD-ImgA\Exe\iDo"
configuration _old_iDo-OAD-ImgB (8051)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=FALSE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_I2C=FALSE; HAL_ADC=TRUE; OLD_BOARD; DEBUG_MEM; DEBUG_STATS
  postbuild: "common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "_old_iDo-OAD-ImgB\Exe\iDo"
  XLINK.XclFile: common\cc2540\cc254x_f256_imgB.xcl
configuration _old_iDo-ImgA-for-flash (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD; OAD_KEEP_NV_PAGES; FEATURE_OAD_BIM; HAL_IMAGE_A; INT_HEAP_LEN=3072; OSAL_CBTIMER_NUM_TASKS=1; HALNODEBUG; HAL_AES_DMA=FALSE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_I2C=FALSE; HAL_ADC=TRUE; OLD_BOARD; DEBUG_MEM; DEBUG_STATS
  postbuild: "perl" "C:\_Software_\util\combine_hex.pl" "C:\Texas Instruments\BLE-CC254x-1.4.0\Projects\ble\util\BIM_custom_dn\cc254x\CC254xF256\Exe\BIM_CC254xF256.hex" "_old_iDo-ImgA-for-flash\Exe\iDo.hex" "_old_iDo-ImgA-for-flash\Exe\combo.hex"
  group APP
    App/: cmdbuffer.c cmdbuffer.h customize.c iDo.c iDo.h iDo_Main.c OSAL_iDo.c tempState.c tempState.h
  group HAL/Common
    hal/common/: hal_drivers.c
  group HAL/Include
    hal/include/: hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
    services/saddr/: saddr.h
  group HAL/Target/Config
    hal/target/CC2541ST/: hal_board_cfg.h
  group HAL/Target/Drivers
    hal/target/CC2540EB/: hal_adc.c
    hal/target/CC2541ST/: hal_assert.c hal_crc.c hal_dma.c hal_flash.c hal_interrupt.c hal_sleep.c hal_startup.c hal_timer.c
    Profiles/Temperature/: SoftwareSPI.c
  group HAL/Target/Includes
    hal/target/CC2541ST/: hal_acc.h hal_aes.h hal_bar.h hal_dma.h hal_gyro.h hal_humi.h hal_i2c.h hal_irtemp.h hal_keys.h hal_mag.h hal_mcu.h hal_sensor.h hal_types.h
  group LIB
    Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group OSAL
    ble/include/: bcomdef.h
    osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    Profiles/Batt/: battservice.c battservice.h
    Profiles/CurrentTime/: currenttime.c currenttime.h
    Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    Include/: gapgattserver.h gattservapp.h
    ble/host/: gatt_uuid.c
    Profiles/MemDump/: memdump.c memdump.h
    Profiles/OAD/: oad.h oad_target.c oad_target.h
    Profiles/DataRecorder/: recorder.c recorder.h
    Profiles/SensorProfile/: st_util.c st_util.h
    Profiles/iDo_Stats/: statistics.c statistics.h
    Profiles/Temperature/: temperature.c temperature.h
  group TOOLS
    config/: buildComponents.cfg
    ./: buildConfig.cfg
    common/cc2540/: OnBoard.c OnBoard.h
