# IAR project iDo.ewp, settings and files
configuration AD8232-OAD-ImgA (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_I2C=TRUE; HAL_ADC=TRUE; ECG_AD8232; OSALMEM_METRICS
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: common; include; hal\include; hal\target\CC2541ST; osal\include; services\saddr; ble\include; ble\controller\phy; ble\controller\include; ble\hci; ble\host; common\cc2540; common\npi\npi_np; Profiles\Roles; Profiles\SensorProfile; Profiles\Keys; Profiles\DevInfo; Profiles\Temperature; Profiles\iDo_Stats; Profiles\HIDDev; Profiles\Batt; Profiles\Oad; Profiles\ECG; Profiles\MemDump; Profiles\Accelerometer; App
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  postbuild: "common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "AD8232-OAD-ImgA\Exe\iDo"
  XLINK.XclFile: common\cc2540\cc254x_f256_imgA.xcl
configuration AD8232-OAD-ImgB (8051)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_I2C=TRUE; HAL_ADC=TRUE; ECG_AD8232; OSALMEM_METRICS
  postbuild: "common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "AD8232-OAD-ImgB\Exe\iDo"
  XLINK.XclFile: common\cc2540\cc254x_f256_imgB.xcl
configuration AD8232-ImgA-for-flash (8051)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD; OAD_KEEP_NV_PAGES; FEATURE_OAD_BIM; HAL_IMAGE_A; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_I2C=TRUE; HAL_ADC=TRUE; ECG_AD8232; OSALMEM_METRICS
  ICC8051.CCIncludePath2: common; include; hal\include; hal\target\CC2541ST; osal\include; services\saddr; ble\include; ble\controller\phy; ble\controller\include; ble\hci; ble\host; common\cc2540; common\npi\npi_np; Profiles\Roles; Profiles\SensorProfile; Profiles\Keys; Profiles\DevInfo; Profiles\Temperature; Profiles\iDo_Stats; Profiles\HIDDev; Profiles\Batt; Profiles\Oad; Profiles\ECG; Profiles\MemDump; Profiles\Accelerometer; Profiles\DataRecorder; App
  postbuild: "perl" "C:\_Software_\util\combine_hex.pl" "C:\Texas Instruments\BLE-CC254x-1.4.0\Projects\ble\util\BIM\cc254x\CC254xF256\Exe\BIM_CC254xF256.hex" "AD8232-ImgA-for-flash\Exe\iDo.hex" "AD8232-ImgA-for-flash\Exe\combo.hex"
configuration E9624-OAD-ImgA (8051)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_I2C=TRUE; HAL_ADC=TRUE; ECG_E9624; OSALMEM_METRICS
  postbuild: "common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "E9624-OAD-ImgA\Exe\iDo"
configuration E9624-OAD-ImgB (8051)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_I2C=TRUE; HAL_ADC=TRUE; ECG_E9624; OSALMEM_METRICS
  postbuild: "common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "E9624-OAD-ImgB\Exe\iDo"
  XLINK.XclFile: common\cc2540\cc254x_f256_imgB.xcl
configuration E9624-ImgA-for-flash (8051)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD; OAD_KEEP_NV_PAGES; FEATURE_OAD_BIM; HAL_IMAGE_A; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_I2C=TRUE; HAL_ADC=TRUE; ECG_E9624; OSALMEM_METRICS
  postbuild: "perl" "C:\_Software_\util\combine_hex.pl" "C:\Texas Instruments\BLE-CC254x-1.4.0\Projects\ble\util\BIM\cc254x\CC254xF256\Exe\BIM_CC254xF256.hex" "E9624-ImgA-for-flash\Exe\iDo.hex" "E9624-ImgA-for-flash\Exe\combo.hex"
  group APP
    App/: acc.h acc_mma8652.c ad8232.c cmdbuffer.c cmdbuffer.h e9624.c ecg_hw_cfg.h ecg_hw_common.c huffman_encode.h huffman_encode_ad8232.c iDo.c iDo.h iDo_Main.c OSAL_iDo.c
  group HAL/Common
    hal/common/: hal_drivers.c
  group HAL/Include
    hal/include/: hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
    services/saddr/: saddr.h
  group HAL/Target/Config
    hal/target/CC2541ST/: hal_board_cfg.h
  group HAL/Target/Drivers
    hal/target/CC2540EB/: hal_adc.c
    hal/target/CC2541ST/: hal_assert.c hal_crc.c hal_dma.c hal_flash.c hal_i2c_mma8652.c hal_interrupt.c hal_sleep.c hal_startup.c hal_timer.c
  group HAL/Target/Includes
    hal/target/CC2541ST/: hal_aes.h hal_bar.h hal_dma.h hal_gyro.h hal_humi.h hal_i2c.h hal_irtemp.h hal_keys.h hal_mag.h hal_mcu.h hal_sensor.h hal_types.h
  group LIB
    Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    common/npi/npi_np/: npi.c npi.h
  group OSAL
    ble/include/: bcomdef.h
    osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    Profiles/Accelerometer/: accelerometer.c accelerometer.h
    Profiles/Batt/: battservice.c battservice.h
    Profiles/ECG/: ecgservice.c ecgservice.h
    Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    Include/: gapgattserver.h gattservapp.h
    ble/host/: gatt_uuid.c
    Profiles/MemDump/: memdump.c memdump.h
    Profiles/OAD/: oad.h oad_target.c oad_target.h
    Profiles/SensorProfile/: st_util.c st_util.h
    Profiles/iDo_Stats/: statistics.c statistics.h
  group TOOLS
    config/: buildComponents.cfg
    ./: buildConfig.cfg
    common/cc2540/: OnBoard.c OnBoard.h
